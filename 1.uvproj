# Keil uVision project 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\STC8A8K64D4资料\CPU-头文件;..\c
  group Source Group 1
    ./: c.c HW.c
    ../STC8A8K64D4资料/CPU-头文件/: STC8G.h
